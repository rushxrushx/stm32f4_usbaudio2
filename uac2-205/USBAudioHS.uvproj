# Keil uVision project USBAudioHS.uvproj, settings and files
target HS (ARM-ADS)
  device: STM32F205RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: USBAudio +hex
  c flags: Optim=3 OneElfS=1 uC99=1
  c define: STM32F40_41xxx,STM32F4XX,USE_STDPERIPH_DRIVER,USE_USB_OTG_HS,USE_ULPI_PHY
  c include: .\HW\HS;.\CMBT;CORE;USER;ALIENTEK;FWLIB\inc;OTGLIB\STM32_USB_OTG_Driver\inc;OTGLIB\STM32_USB_Device_Library\Core\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group cortexlib
    ./CORE/: startup_stm32f40_41xxx.s
  group fwlib
    ./FWLIB/src/: misc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c
  group usbotglib
    ./OTGLIB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group usbotgdevice
    ./OTGLIB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ./USER/: usbd_usr.c usbd_desc.c usb_bsp.c
    ./FWLIB/src/: stm32f4xx_exti.c
  group alientek
    ./ALIENTEK/: usart.c
  group hw
    ./HW/HS/: audio_out.c gpio.c spi1.c
  group user
    ./USER/: main.c stm32f4xx_it.c system_stm32f4xx.c usbd_audio2_core.c
  group cmbacktrace
    ./CMBT/: cm_backtrace.c
    ./CMBT/fault_handler/keil/: cmb_fault.S
